* /home/ameya/eSim-Workspace/10bb/10bb.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Wed Jul 29 12:14:01 2020

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R6  /vdd Net-_R6-Pad2_ 1k
R8  Net-_R6-Pad2_ Net-_R7-Pad1_ 1k
R7  Net-_R7-Pad1_ Net-_R14-Pad1_ 1k
R5  Net-_R14-Pad1_ GND 1k
v1  /vdd GND DC
v2  d0 GND pulse
v3  d1 GND pulse
X2  d0 /vdd GND Net-_R7-Pad1_ Net-_R6-Pad2_ Net-_X2-Pad6_ swi
X4  d0 /vdd GND Net-_R14-Pad1_ Net-_R7-Pad1_ Net-_X4-Pad6_ swi
X6  d1 /vdd GND Net-_X4-Pad6_ Net-_X2-Pad6_ /o1 swi
U2  /o1 plot_v1
v4  d2 GND pulse
v5  d3 GND pulse
v6  d4 GND pulse
v7  d5 GND pulse
v8  d6 GND pulse
v9  d7 GND pulse
v10  d8 GND pulse
v11  d9 GND pulse
R14  Net-_R14-Pad1_ Net-_R14-Pad2_ 1k
R16  Net-_R14-Pad2_ Net-_R15-Pad1_ 1k
R15  Net-_R15-Pad1_ Net-_R13-Pad1_ 1k
R13  Net-_R13-Pad1_ GND 1k
X9  d2 /vdd GND Net-_R13-Pad1_ Net-_R15-Pad1_ Net-_X12-Pad4_ swi
X10  d2 /vdd GND Net-_R15-Pad1_ Net-_R14-Pad2_ Net-_X10-Pad6_ swi
X12  d3 /vdd GND Net-_X12-Pad4_ Net-_X10-Pad6_ /o2 swi
U4  /o2 plot_v1
R18  Net-_R17-Pad1_ Net-_R18-Pad2_ 1k
R20  Net-_R18-Pad2_ Net-_R19-Pad1_ 1k
R19  Net-_R19-Pad1_ Net-_R13-Pad1_ 1k
R17  Net-_R17-Pad1_ GND 1k
X13  d4 /vdd GND Net-_R17-Pad1_ Net-_R18-Pad2_ Net-_X13-Pad6_ swi
X14  d4 /vdd GND Net-_R18-Pad2_ Net-_R19-Pad1_ Net-_X14-Pad6_ swi
X15  d5 /vdd GND Net-_X13-Pad6_ Net-_X14-Pad6_ /o3 swi
U5  /o3 plot_v1
R2  Net-_R17-Pad1_ Net-_R2-Pad2_ 1k
R4  Net-_R2-Pad2_ Net-_R3-Pad1_ 1k
R3  Net-_R3-Pad1_ Net-_R1-Pad1_ 1k
R1  Net-_R1-Pad1_ GND 1k
X1  d6 /vdd GND Net-_R1-Pad1_ Net-_R3-Pad1_ Net-_X1-Pad6_ swi
X3  d6 /vdd GND Net-_R3-Pad1_ Net-_R2-Pad2_ Net-_X3-Pad6_ swi
X5  d7 /vdd GND Net-_X1-Pad6_ Net-_X3-Pad6_ /o4 swi
U1  /o4 plot_v1
R10  Net-_R1-Pad1_ Net-_R10-Pad2_ 1k
R12  Net-_R10-Pad2_ Net-_R11-Pad1_ 1k
R11  Net-_R11-Pad1_ Net-_R11-Pad2_ 1k
R9  Net-_R11-Pad2_ GND 1k
X7  d8 /vdd GND Net-_R11-Pad2_ Net-_R11-Pad1_ Net-_X11-Pad4_ swi
X8  d8 /vdd GND Net-_R11-Pad1_ Net-_R10-Pad2_ Net-_X11-Pad5_ swi
X11  d9 /vdd GND Net-_X11-Pad4_ Net-_X11-Pad5_ /o5 swi
U3  /o5 plot_v1

.end
